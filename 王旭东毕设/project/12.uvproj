# Keil uVision project 12.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 12 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\user;..\BSP\inc
  group user
    ../user/: bsp_main.c
    $TC_ROOT$/../../Users/APTX4/Desktop/12/user/: inc.h
  group hardware
    ../BSP/src/: bsp_keypad.c bsp_lcd.c bsp_tcl1543.c bsp_usart.c bsp_timer.c
  group core
    ../user/: STARTUP.A51
  group readme
    ../readme/: readme.txt
