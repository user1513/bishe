# Keil uVision project 避障、循迹、测速小车.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 避障、循迹、测速小车 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Csb.c delay.c Lcd1602.c main.c TimeFile.c
