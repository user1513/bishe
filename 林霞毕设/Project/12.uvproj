# Keil uVision project 12.uvproj, settings and files
target project (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 12 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\user;..\BSP\inc
  group user
    ../user/: bsp_main.c inc.h
  group hardware
    ../BSP/src/: bsp_keypad.c bsp_lcd.c bsp_usart.c bsp_timer.c bsp_ds1302.c bsp_sht11.c
  group core
    ../user/: STARTUP.A51
  group readme
    ../readme/: readme.txt
